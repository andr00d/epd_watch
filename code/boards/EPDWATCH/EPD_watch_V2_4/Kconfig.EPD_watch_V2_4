## code/boards/EPDWATCH/EPD_watch_V2_4/board.yml
```yaml
board:
  name: EPD_watch_V2_4
  full_name: EPD_watch_V2_4
  vendor: EPDWATCH
  socs:
    - name: nrf52832
```
